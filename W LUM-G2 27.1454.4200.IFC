Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: WLUM 27_44_75W-1454.IFC
Time: 2023-10-23T07:02:51
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: WLUM 27_44_75W-1454
In: Default Storey
SolidWorks Custom Properties - Description: PWR(27,44,75W);LUM.FLUX(4200,7050,11000lm)
PSet_Mass_Property - Mass Measure: 9.66505; Area Measure: 0.502465 m2; Volume Measure: 0.00966505 m3

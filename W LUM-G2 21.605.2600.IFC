Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: WLUM 21W-605.IFC
Time: 2023-10-23T07:02:13
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: WLUM 21W-605
In: Default Storey
SolidWorks Custom Properties - Description: PWR(21W);LUM.FLUX(2600lm)
PSet_Mass_Property - Mass Measure: 3.81339; Area Measure: 0.205338 m2; Volume Measure: 0.00381339 m3

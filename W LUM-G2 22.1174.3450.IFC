Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: WLUM 22_34_54W-1174.IFC
Time: 2023-10-23T07:02:30
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: WLUM 22_34_54W-1174
In: Default Storey
SolidWorks Custom Properties - Description: PWR(22,34,54W);LUM.FLUX(3450,5300,8800lm)
PSet_Mass_Property - Mass Measure: 7.73517; Area Measure: 0.404472 m2; Volume Measure: 0.00773517 m3
